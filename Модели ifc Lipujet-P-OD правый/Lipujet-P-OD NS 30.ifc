Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: Project Number
Time: 2019-08-12T12:11:03
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20150220_1215(x64) - Exporter 16.0.428.0 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon Aug 12 12:11:03 2019 * Host: IN-BLR-WS-1079 * Database: C:\Users\KSUBRA~1\AppData\Local\Temp\{67B1D8F2-4772-4D95-941A-3098A22AE324}\ifc * Database version: 5507 * Database creation date: Mon Aug 12 12:11:02 2019 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Mon Aug 12 12:11:02 2019 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon Aug 12 12:11:02 2019 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 51, 30, 23, 112487; RefLongitude: 0, -7, -37, -956022; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuildingStorey, Level 0
LongName: Level 0; Elevation: 0 mm
Other - Category: Levels; Family Name: Level; Family: Level: Circle Head - Project Datum; Family and Type: Level: Circle Head - Project Datum; Type: Level: Circle Head - Project Datum; Type Id: Level: Circle Head - Project Datum
Identity Data - Type Name: Circle Head - Project Datum; Building Story: yes; Name: Level 0; Structural: no
Graphics - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: Anno_Level_Head_Circle: Standard; Symbol at End 1 Default: yes; Symbol at End 2 Default: no
Constraints - Elevation Base: Project Base Point; Elevation: 0 mm
Dimensions - Computation Height: 0 mm

# IfcBuildingElementProxy: NS30, ME_PE_UN_oval big LipuJet-P-OD extension stage 1_ACO:NS30:298680
In: Level 0
Type - Description: ACO grease separator NS 30; PredefinedType: USERDEFINED; Material: HDPE, Black
Type - General - installation_manual: http://www.aco-haustechnik.de/fileadmin/aco_haustechnik/documents/Einbauvorschlag/Einbauvorschlag-Kapitel-10.Fettabscheider.pdf; instructions_for_use: http://www.aco-haustechnik.de/catalog/ACO-HT/de/doc/00/13/000/Gebrauchsanleitung_Fettabscheider_zur_Freiaufstellung_-_Sonderbauformen_NS15_bis_NS60_238914.pdf; RSen_C_code_ETIM: EC010271; RSen_C_code_manufacturer_gln: 4399901709010; RSen_C_content_creator: Itannex bv; RSen_C_content_version: 1.0; RSen_C_info_technical: http://www.aco-haustechnik.de/produkte/clean/fettabscheider/freiaufstellung/vollentsorgung/ovale-grossbauform-polyethylen-pe-hd/lipujet-p-od/; RSen_C_intended_use: Entwässerungssysteme
Type - Identity Data - Description: ACO grease separator NS 30; LOD: LOD 400; Manufacturer: ACO; Model: Grease separator NS 30; OmniClass Number: 23.70.50.00; OmniClass Title: Liquid Waste Handling Services; Type Comments: Building Supervisory Authority approval Z-54.1-414; Type Name: NS30
Type - Materials and Finishes - RSen_C_material: HDPE, Black
Type - Other - Category: Mechanical Equipment; Family Name: ME_PE_UN_oval big LipuJet-P-OD extension stage 1_ACO
Pset_BuildingElementProxyCommon - Reference: NS30
Pset_ManufacturerTypeInformation - Manufacturer: ACO
Constraints - clearance_zone: no; DN_sanitary: yes; filling_device: yes; grease_measure_device: no; heating_rod: no; Host: Level : Level 0; inlet_angle: 0 deg; left: no; Level: Level: Level 0; logo: yes; OD_sanitary: no; Offset: 0 mm; right: yes; sight_glass: yes
Dimensions - Area: 30.4197 m2; DN: 250 mm; H1: 1850 mm; H2: 1740 mm; H3: 1300 mm; H4: 1230 mm; L1: 4800 mm; L2: 4560 mm; Volume: 0.000441765 m3; W2: 1260 mm
General - RSen_P_c01_diameter: 250 mm; RSen_P_c02_diameter: 250 mm; RSen_P_c03_diameter: 100 mm; RSen_P_c04_diameter: 20 mm; RSen_P_c05_diameter: 65 mm
Identity Data - Mark: 1; RSen_C_code_article: 3830.45.42; RSen_C_code_gtin: 4002626764379; RSen_C_description: ACO Fettabschd. LipuJet-P-OD NS 30, mit Absaugeinrichtung Ausführung rechts; RSen_C_product_assortment: Grease separators; RSen_C_type_comments: Grease separator plant as per DIN EN 1825 and DIN 4040-100
Mechanical - RSen_P_c04_flow: 0 m3/s; System Classification: Sanitary,Vent,Domestic Cold Water,Other
Model Properties - clearance_back: 680 mm; clearance_entry: 3400 mm; clearance_exit: 2500 mm; clearance_front: 1230 mm; clearance_top: 2450 mm; drain_D: 75 mm; drain_H: 100 mm; drain_X: 2680 mm; drain_Y: 700 mm
Other - cold_water_connector: cw in; connector_escape_message: Nicht verwenden; extension_stage_lookup_table_name: oval_big_lipujet-p-od; Family: ME_PE_UN_oval big LipuJet-P-OD extension stage 1_ACO: NS30; Family and Type: ME_PE_UN_oval big LipuJet-P-OD extension stage 1_ACO: NS30; lookup_table_name: oval_big_lipujet_p; no_option: 0; option: 1; options_lookup_table_name: oval_big_lipujet_p_options; Type: ME_PE_UN_oval big LipuJet-P-OD extension stage 1_ACO: NS30; Type Id: ME_PE_UN_oval big LipuJet-P-OD extension stage 1_ACO: NS30; vent_DN: 100 mm; vent_OD: 110 mm
Phasing - Phase Created: New Construction
Plumbing - grease_store_capacity: 1.29 m3; overall_capacity: 5.55 m3; sludge_trap_capacity: 3.02 m3
Structural - RSen_S_gross_mass: 671.917; RSen_S_net_mass: 671.917

# IfcBuildingElementProxy: std, ZZZ_do not use_ME_PE_UN_oval big lipujet p options_ACO:std:298681
In: Level 0
Type - PredefinedType: USERDEFINED; Material: Plastic, White, HDPE, Red, HDPE, Black
Type - Identity Data - Manufacturer: ACO; OmniClass Number: 23.70.50.00; OmniClass Title: Liquid Waste Handling Services; Type Name: std
Type - Other - Category: Mechanical Equipment; Family Name: ZZZ_do not use_ME_PE_UN_oval big lipujet p options_ACO
Pset_BuildingElementProxyCommon - Reference: std
Pset_ManufacturerTypeInformation - Manufacturer: ACO
Constraints - filling_device: yes; grease_measure_device: no; heating_rod: no; inlet_angle: 0 deg; left: no; logo: yes; Offset: 0 mm; right: yes; Host: Level : Level 0; Level: Level: Level 0; Moves With Nearby Elements: no
Dimensions - Area: 26.1792 m2; cover_D: 490 mm; cover_H: 53 mm; cover1_X: 630 mm; cover2_X: 4200 mm; DN: 250 mm; drain_D: 69 mm; drain_L: 630 mm; drain_X: 1930 mm; drain_Z: 75 mm; H1: 1850 mm; H2: 1740 mm; H3: 1300 mm; H4: 1230 mm; H5: 15 mm; H6: 524 mm; H7: 944 mm; L1: 4800 mm; L2: 4560 mm; L3: 4500 mm; L4: 4633 mm; logo_X: 3070 mm; logo_Z: 610 mm; vent_D: 110 mm; vent_H: 50 mm; vent_X: 2740 mm; vent_Y: 1000 mm; Volume: 8.9018 m3; W1: 1340 mm; W2: 1260 mm; W3: 1200 mm; W4: 390 mm; waterinlet_angle: 50 deg; waterinlet_D: 90 mm; waterinlet_L: 686 mm; waterinlet_X: 3933 mm; waterinlet_Z: 1526 mm; window1_X: 1490 mm; window1_Z: 705 mm; window2_X: 3070 mm; window2_Z: 1147 mm
General - RSen_P_c01_diameter: 250 mm; RSen_P_c02_diameter: 250 mm
Identity Data - Mark: 2
Materials and Finishes - RSen_C_material: HDPE, Black
Model Properties - grease_measure_end_angle: 95 deg; grease_measure_start_angle: 90 deg; grease_measure_X: 2160 mm; heatrod_position: 90 deg; heatrod_X: 3070 mm; heatrod_Z: 897 mm
Other - connection_radius: 125 mm; disabled_options: no; drain_position: 90 deg; Family: ZZZ_do not use_ME_PE_UN_oval big lipujet p options_ACO: std; Family and Type: ZZZ_do not use_ME_PE_UN_oval big lipujet p options_ACO: std; grease_measure_option: 1; heatrod_option: 1; L1_half: 2400 mm; L2_calculated: 3300 mm; logo_position: 90 deg; lookup_table_name: oval_big_lipujet_p; options_lookup_table_name: oval_big_lipujet_p_options; Type: ZZZ_do not use_ME_PE_UN_oval big lipujet p options_ACO: std; type_index: 30; Type Id: ZZZ_do not use_ME_PE_UN_oval big lipujet p options_ACO: std; W3_half: 600 mm; water_inlet_end_angle: 45 deg; water_inlet_option: 1; water_inlet_start_angle: 40 deg; waterinlet_bend_calculated: 91 mm; waterinlet_H_calculated: 324 mm; window_option: 0; window_position: 90 deg
Phasing - Phase Created: New Construction

# IfcFlowController: std, ZZZ_do not use_ME_ST_WPB_filling device for LipuJet-P_ACO:std:298684
In: Level 0
Type - Description: ACO filling device; PredefinedType: FAUCET; Material: Stainless Steel, Brushed
Type - Constraints - Default Elevation: 1219.2 mm
Type - General - RSen_C_code_ETIM: EC010071; RSen_C_code_manufacturer_gln: 4399901709010; RSen_C_content_creator: Itannex bv; RSen_C_content_version: 1.0; RSen_P_c01_diameter: 20 mm
Type - Identity Data - Description: ACO filling device; LOD: LOD 400; Manufacturer: ACO; Model: Filling device for LipuJet-P; OmniClass Number: 23.70.50.00; OmniClass Title: Liquid Waste Handling Services; Type Comments: Free outlet as per DIN 1988 Part 4; Type Name: std
Type - Materials and Finishes - RSen_C_material: Stainless Steel, Brushed
Type - Other - Category: Mechanical Equipment; Family Name: ZZZ_do not use_ME_ST_WPB_filling device for LipuJet-P_ACO
Type - Plumbing - p_c01_flow: 0.003 m3/s
Type - Structural - RSen_S_net_mass: 3.5
Pset_ManufacturerTypeInformation - Manufacturer: ACO
Pset_DistributionFlowElementCommon - Reference: std
Constraints - Level: Level: Level 0; Moves With Nearby Elements: no; Host: Level : Level 0; Offset: 1750 mm
Dimensions - Area: 0.0761672 m2; Volume: 0.00141803 m3
Identity Data - Mark: 5; RSen_C_code_article: 3300.11.22; RSen_C_code_gtin: 04002626299253; RSen_C_description: ACO Fülleinheit für LipuJet-P-OB,-P-OD,-P-RB,-P-RD; RSen_C_product_assortment: Grease separators
Other - option: 1; Family: ZZZ_do not use_ME_ST_WPB_filling device for LipuJet-P_ACO: std; Family and Type: ZZZ_do not use_ME_ST_WPB_filling device for LipuJet-P_ACO: std; Type: ZZZ_do not use_ME_ST_WPB_filling device for LipuJet-P_ACO: std; Type Id: ZZZ_do not use_ME_ST_WPB_filling device for LipuJet-P_ACO: std
Phasing - Phase Created: New Construction

# IfcWindow: std (2)
In: Level 0
Type - Description: ACO viewing window; ParameterTakesPrecedence: no; Sizeable: no; Material: HDPE, Red, HDPE, Black, HDPE, Grey
Type - Constraints - Default Elevation: 1219.2 mm
Type - General - RSen_C_code_ETIM: EC011162; RSen_C_code_manufacturer_gln: 4399901709010; RSen_C_content_creator: Itannex bv; RSen_C_content_version: 1.0; RSen_C_intended_use: Entwässerungssysteme
Type - Identity Data - Description: ACO viewing window; LOD: LOD 400; Manufacturer: ACO; Model: Viewing window; OmniClass Number: 23.70.50.00; OmniClass Title: Liquid Waste Handling Services; Type Comments: Nominal width: DN 200; Type Name: std
Type - Materials and Finishes - RSen_C_material: HDPE, Grey
Type - Other - Category: Mechanical Equipment; Family Name: ZZZ_do not use_ME_PE_WPB_viewing window LipuJet-P_ACO
Type - Structural - RSen_S_net_mass: 5
OverallHeight: 75 mm; OverallWidth: 250 mm
Pset_WindowCommon - Reference: std; IsExternal: no
Pset_ManufacturerTypeInformation - Manufacturer: ACO
Constraints - Level: Level: Level 0; Moves With Nearby Elements: no; Host: Level : Level 0
Dimensions - Area: 0.0878948 m2; Volume: 0.00175086 m3
Identity Data - RSen_C_code_article: 3300.11.10; RSen_C_code_gtin: 04002626130280; RSen_C_description: ACO Schauglas LW 200 f. LipuJet-P-OB,-P-OD,-P-RB,-P-RD; RSen_C_product_assortment: Grease separators
Other - Family: ZZZ_do not use_ME_PE_WPB_viewing window LipuJet-P_ACO: std; Family and Type: ZZZ_do not use_ME_PE_WPB_viewing window LipuJet-P_ACO: std; option: 0; Type: ZZZ_do not use_ME_PE_WPB_viewing window LipuJet-P_ACO: std; Type Id: ZZZ_do not use_ME_PE_WPB_viewing window LipuJet-P_ACO: std
Phasing - Phase Created: New Construction
Name (ZZZ_do not use_ME_PE_WPB_viewing window LipuJet-P_ACO:std:...) | Offset (mm) | Mark
298682 | 705 | 3
298683 | 1147 | 4
